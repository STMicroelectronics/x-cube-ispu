<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ISM330IS_DataLogExtended.ewp</path>
  </project>
  <batchBuild />
</workspace>
