# Keil uVision project LSM6DSO16IS_DataLogExtended.uvprojx, settings and files
target LSM6DSO16IS_DataLogExtended (ARM-ADS)
  device: STM32U575ZITxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: LSM6DSO16IS_DataLogExtended +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/lis2mdl;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps22hh;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/lsm6dso16is
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User
    ../Src/: main.c int_pins_interface.c custom_ispu_motion_sensors.c custom_ispu_motion_sensors_ex.c custom_mems_control.c custom_mems_control_ex.c com.c demo_serial.c sensor_commands.c serial_protocol.c app_x-cube-ispu.c custom_motion_sensors.c custom_motion_sensors_ex.c custom_env_sensors.c custom_env_sensors_ex.c stm32u5xx_nucleo_bus.c stm32u5xx_nucleo.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is_reg.c lsm6dso16is.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
